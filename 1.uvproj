# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Objects;.\System;.\Driver
  group Source Group 1
    ./User/: main.c STARTUP.A51
    ./System/: delay.c delay.h timer0.c timer0.h
    ./Driver/: eeprom.c eeprom.h key.c key.h lcd.c lcd.h
